# Keil uVision project template.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Library\inc;..\Core;..\User;..\User;..\System\SysTick;..\System\Sys;..\Hardware\Usart1;..\App\Util;..\Hardware\wdog;..\Hardware\Adc1;..\Hardware\OledI2c;..\Hardware\Oled;..\Hardware\Timer3;..\App\Control;..\Hardware\Photogate;..\Hardware\DigitalTube;..\App\Pid;..\Hardware\Motor;..\Hardware\Key;..\Hardware\ReedSwitch;..\Hardware\Timer2Pwm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../System/SysTick/: systick.c
    ../System/Sys/: system.h
  group Hardware
    ../Hardware/Usart1/: usart1_dma.c
    ../Hardware/wdog/: wdog.c
    ../Hardware/Adc1/: adc1.c
    ../Hardware/OledI2c/: oled_iic.c
    ../Hardware/Oled/: oled_font.c oled.c
    ../Hardware/Timer3/: timer3.c
    ../Hardware/Timer2Pwm/: timer2_pwm.c
    ../Hardware/DigitalTube/: digital_tube.c
    ../Hardware/Photogate/: photogate.c
    ../Hardware/Motor/: Motor.c
    ../Hardware/Key/: key.c
    ../Hardware/ReedSwitch/: reed_switch.c
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group App
    ../App/Util/: util.c
    ../App/Control/: control.c
    ../App/Pid/: pid.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.4.0
